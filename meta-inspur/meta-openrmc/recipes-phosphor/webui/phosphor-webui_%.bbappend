FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI = "git://github.com/inspur-bmc/OR-web;protocol=https"
SRCREV = "01f344122eabed24ba70e6740526ae7cb4f22cdb"
